# Keil uVision project sd_card.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sd_card
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: .\FATFS;.\Middlewares\Third_Party\FatFs\src;..\SD_Card;.\FATFS\App;.\FATFS\Target
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Inc
    ./: main.h fatfs_sd.h delay.h spi.h uart.h gpio.h
    ./FATFS/Target/: user_diskio.h
    ./FATFS/App/: fatfs.h
  group Src
    ./: main.c fatfs_sd.c delay.c spi.c uart.c gpio.c
    ./FATFS/Target/: user_diskio.c
    ./FATFS/App/: fatfs.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
